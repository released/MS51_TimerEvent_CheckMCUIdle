# Keil uVision project Project_temp.uvproj, settings and files
target Project_temp (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project_temp +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\Project
  link misc: REMOVEUNUSED
  group Source
    ../: main.c misc_config.c cpu_load_monitor.c timer_service.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
